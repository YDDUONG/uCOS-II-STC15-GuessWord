# Keil uVision project uCosii_51.uvproj, settings and files
target uCOS_II_51 (MCS-51)
  device: STC15W4K32S4 STC
  cpu: IRAM(0-0xFF) XRAM(0-0xEFF) IROM(0-0xEFF8) CLOCK(35000000) MODP2
  output: uCOS-II +hex
  c flags: Optimize=8
  group user_app
    ./Source/: main.c
    ./User/: STARTUP.A51
    ./Source/other/: keyAction.c keyBoard.c LCD12864.c timeN.c interface.c
  group uCosii
    ./uCosii/: OS_CORE.C OS_CPU_C.C OS_MBOX.C OS_MEM.C OS_Q.C OS_SEM.C OS_TASK.C OS_TIME.C OS_CPU_A.ASM
